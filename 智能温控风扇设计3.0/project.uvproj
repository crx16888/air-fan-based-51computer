# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Delay.h Int0.c Int0.h IR.c IR.h Key.c Key.h main.c Motor.c Motor.h Nixie.c Nixie.h Timer0.c Timer0.h Timer1.c Timer1.h DS18B20.c DS18B20.h LCD1602.c LCD1602.h OneWire.c OneWire.h Timer2.c Timer2.h
